# Keil uVision project LCD_menu.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: LCD_menu +hex
  c flags: Optim=4
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,STM32F4XX,KEIL_IDE,TM_DISCO_STM32F4_DISCOVERY,PLL_M=8,PLL_N=336,PLL_P=2,PLL_Q=7,__KEIL__,
  c include: ..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Device\ST\STM32F4xx\Include;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\CMSIS\Include;..\00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS\STM32F4xx_StdPeriph_Driver\inc;..\TM;.\User;..\FreeRTOSV8.2.1\FreeRTOS\Source\include;..\FreeRTOSV8.2.1\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Menu;..\STM32F4_Discovery;..\fat_fs\ff11\src
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./: startup_stm32f40xx.s
  group User
    ./User/: system_stm32f4xx.c main.c FreeRTOSConfig.h stm32f4xx_it.c defines.h USART.c XPT2046.c
  group TM
    ../TM/: tm_stm32f4_ili9341.c tm_stm32f4_spi.c tm_stm32f4_gpio.c tm_stm32f4_fonts.c tm_stm32f4_delay.c tm_stm32f4_timer_properties.c
  group FreeRTOS
    ../FreeRTOSV8.2.1/FreeRTOS/Source/: queue.c tasks.c list.c
    ../FreeRTOSV8.2.1/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../FreeRTOSV8.2.1/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Std_Peripheral_Driver
    ../00-STM32F4xx_STANDARD_PERIPHERAL_DRIVERS/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_spi.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_syscfg.c
  group Menu
    ../Menu/: menu_system.c menu_functions.c menu_event.c menu_button.c
  group STM32F4_Discovery
    ../STM32F4_Discovery/: stm32f4_discovery.c
